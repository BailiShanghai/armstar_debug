# Keil uVision project bk7236_spe.uvprojx, settings and files
target secure_world (6160000::V6.16::ARMCLANG)
  device: STAR_SE ArmChina
  pack: ArmChina.STAR.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: bk7236_spe
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c --output=#L.txt #L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __EN_ICACHE __EN_DCACHE VERSION_STRING=\"Bootrom_v1.0\" BUILD_TYPE=\"debug\" CONFIG_DEBUG PAL_ASSERT_ENABLE SECURE_BOOT MBEDTLS_WITH_DUBHE ARM_CE_DUBHE ARM_CE_DUBHE_OTP __thumb__
  c include: E:\Keil536\ArmChina\STAR\2.0.0\CMSIS\Core\Include;E:\Keil536\ArmChina\STAR\2.0.0\Device\ArmChina\STAR\Include;.\BootROM\device;.\BootROM\drvs;.\BootROM\drvs\inc;.\BootROM\arch\arm-m;.\BootROM\inc;.\BootROM\inc\hal;.\BootROM\inc\pal;.\BootROM\hal\inc;.\BootROM\hal;.\BootROM\utils;.\BootROM\utils\prng;.\BootROM\utils\stdout;.\BootROM\utils\string;.\BootROM\utils\inc;.\BootROM\utils\mutex;.\BootROM\utils\oal;.\BootROM\apps\inc;.\BootROM\utils\ce_lite\include;.\BootROM\utils\ce_lite\library\ce_lite\inc;.\BootROM\inc\secure_boot;.\BootROM\hal\bk7236_v2022;.\BootROM\board\bk7236_v2022\inc;.\BootROM\board\bk7236_v2022\layout\bootrom;.\BootROM\board\bk7236_v2022\layout;.\BootROM\board\bk7236_v2022;.\BootROM\drvs\flash;.\BootROM\hal\bk7236_v2022\devices\uart;.\BootROM\hal\bk7236_v2022\devices\flash;.\BootROM\hal\bk7236_v2022\devices\common;.\BootROM\verification;.\BootROM\hal\bk7236_v2022\devices\psram;.\BootROM\hal\bk7236_v2022\devices\sys_ctrl;.\BootROM\drvs\bk_gpio;.\BootROM\hal\bk7236_v2022\devices\qspi
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20100000 size 0x40000
  scatter file: .\RTE\Device\STAR_SE\soc_bk7236.sct
  group app
    ./BootROM/bs/: bs.c
    ./BootROM/apps/: app.c verification.c
  group secure_boot
    ./BootROM/utils/heap/: heap.c
    ./BootROM/utils/stdout/: printf-stdarg.c
    ./BootROM/utils/string/: string.c
    ./BootROM/utils/oal/: oal.c
    ./BootROM/hal/: drv_dep.c flash_operation.c hal_boot_control.c hal_comm_channel.c hal_flash.c hal_fota.c hal_irq.c hal_otp_no_dubhe.c hal_otp_with_dubhe.c hal_rng.c hal_secure_boot.c hal_secure_debug.c hal_trng_calibration.c
    ./BootROM/hal/crypto/: hal_crypto_aes.c hal_crypto_ecdsa.c hal_crypto_hash.c hal_crypto_rsa.c
    ./BootROM/pal/: pal_heap.c pal_log.c pal_string.c pal_time.c
    ./BootROM/drvs/arm_uart/: uart_cmsdk_apb.c uart_drv_to_dev.c
    ./BootROM/drvs/spi/spi_pl022/: spi_pl022.c
    ./BootROM/drvs/spi/: spi_drv_to_dev.c
    ./BootROM/utils/memmgmt/: heap_4.c
    ./BootROM/utils/ce_lite/library/: aes.c bignum.c ecdsa.c ecp.c otp.c platform.c rsa.c sha1.c sha256.c sm2dsa.c sm3.c sm4.c
    ./BootROM/utils/ce_lite/library/ce_lite/src/: ce_aca.c ce_aca_bn.c ce_aca_ecdsa.c ce_aca_ecp.c ce_aca_rsa.c ce_aca_sm2dsa.c ce_cipher.c ce_common.c ce_config.c ce_hash.c ce_otp.c ce_trng.c
    ./BootROM/examples/bootrom/: BootRom_main.c secure_boot_sample.c
    ./BootROM/arch/arm-m/: jump.c
    ./BootROM/sec_boot/secureboot/secure_boot_core/src/: secure_boot_core.c secureboot_verifier.c
    ./BootROM/drvs/flash/: flash_drv_to_dev.c
    ./BootROM/device/: device.c
    ./BootROM/utils/ce_lite/examples/: hash_example.c aes_example.c
  group bk7236
    ./BootROM/hal/bk7236_v2022/: hal_platform.c
    ./BootROM/hal/bk7236_v2022/devices/uart/: uart_cmsdk_device.c bk_uart.c
    ./BootROM/hal/bk7236_v2022/devices/spi/: spi_device.c
    ./BootROM/hal/bk7236_v2022/devices/flash/: flash_device.c bk_flash.c
    ./BootROM/hal/bk7236_v2022/devices/psram/: bk_psram.c
    ./BootROM/drvs/bk_gpio/: bk_gpio.c
    ./BootROM/hal/bk7236_v2022/devices/qspi/: bk_qspi.c
  group nsc_func
    ./nsc/: nsc_functions.c
  group verification
    ./BootROM/verification/: tt_idau.c aca_sram.c te_ram.c sharedm.c secure.c sig_hash256.c trng.c alg_aes.c psram.c dtcm.c mpc.c vrf_flash.c boot_wr_flash.c boot_wr_flash_test.c itcm.c qspi.c data_cache.c post_sim.c privilege_peri.c secure_flash.c debug.c
software components: CMSIS:CORE 5.6.0, CMSIS Driver:USART:STAR USART 1.1.0, Device:Startup 1.1.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
