# Keil uVision project SST26VF064B.uvprojx, settings and files
target STAR (6160000::V6.16::ARMCLANG)
  device: STAR_CU ArmChina
  pack: ArmChina.STAR.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: SST26VF064B
  AfterMake: cmd.exe /C copy "Objects\%L" .\@L.FLM
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c include: .\Source\app;.\Source\driver
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./Source/prg/: FlashPrg.c
    ./Source/app/: Flash_app.c Flash_app.h
  group Device Description
    ./Source/prg/: FlashDev.c FlashOS.h
  group Device Driver
    ./Source/driver/: Flash_api.c Flash_api.h Flash_driver.c Flash_driver.h
software components: CMSIS:CORE 5.5.0, CMSIS Driver:QSPI(Driver):STAR QCU 1.0.0
