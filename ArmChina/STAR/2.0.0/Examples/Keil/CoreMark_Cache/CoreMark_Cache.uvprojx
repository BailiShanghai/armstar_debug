# Keil uVision project CoreMark_Cache.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STAR_SP ArmChina
  pack: ArmChina.STAR.1.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: CoreMark_Cache
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: __EN_ICACHE=1 __EN_DCACHE=1  SEED_METHOD=SEED_ARG COMPILER_VERSION=__VERSION__ COMPILER_FLAGS=\"-Omax\"
  c misc: -Omax
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\RTE\STAR_ac6.sct
  group Source Group 1
    ./Source/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h main.c
software components: CMSIS:CORE 5.4.0, CMSIS Driver:USART:STAR USART 1.0.0, Device:Startup 1.1.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
